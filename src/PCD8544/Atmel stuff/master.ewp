# IAR project master.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm162.xcl
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ./: AVR151_Master.c
